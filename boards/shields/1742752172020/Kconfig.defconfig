## boards/shields/1742752172020/Kconfig.defconfig
```kconfig
if SHIELD_1742752172020
config ZMK_KEYBOARD_NAME
    default "1742752172020"

endif
```
